# Keil uVision project iot_lwip_mqtt_subscriber_pca10040_s132.uvproj, settings and files
target nrf52832_xxaa (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 wLevel=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD MBEDTLS_CONFIG_FILE=<nrf_tls_config.h> NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=5 NRF_TLS_MAX_INSTANCE_COUNT=1 S132 SOFTDEVICE_PRESENT SWI_DISABLE0 __HEAP_SIZE=0 __STACK_SIZE=4608
  c misc: --c99 --reduce_paths
  c include: ..\..\..\config;..\..\..\..\..\..\..\..\components\iot\errno;..\..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_ipsp;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\..\components\device;..\..\..\..\..\..\..\..\components\drivers_ext\tls;..\..\..\..\..\..\..\..\components\drivers_ext\tls\mbedtls\tls\config;..\..\..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\..\..\components\drivers_nrf\comp;..\..\..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\..\components\drivers_nrf\i2s;..\..\..\..\..\..\..\..\components\drivers_nrf\lpcomp;..\..\..\..\..\..\..\..\components\drivers_nrf\pdm;..\..\..\..\..\..\..\..\components\drivers_nrf\power;..\..\..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\..\..\components\drivers_nrf\pwm;..\..\..\..\..\..\..\..\components\drivers_nrf\qdec;..\..\..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\..\..\components\drivers_nrf\swi;..\..\..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\..\..\..\components\drivers_nrf\twis_slave;..\..\..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\..\..\components\drivers_nrf\usbd;..\..\..\..\..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\..\..\..\..\components\iot\ble_6lowpan;..\..\..\..\..\..\..\..\components\iot\common;..\..\..\..\..\..\..\..\components\iot\context_manager;..\..\..\..\..\..\..\..\components\iot\iot_timer;..\..\..\..\..\..\..\..\components\iot\medium;..\..\..\..\..\..\..\..\components\iot\medium\ble_ncfgs;..\..\..\..\..\..\..\..\components\iot\medium\commissioning;..\..\..\..\..\..\..\..\components\iot\mqtt;..\..\..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\..\components\libraries\cli;..\..\..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\..\..\..\components\libraries\experimental_log;..\..\..\..\..\..\..\..\components\libraries\experimental_log\src;..\..\..\..\..\..\..\..\components\libraries\experimental_memobj;..\..\..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\..\components\libraries\twi;..\..\..\..\..\..\..\..\components\libraries\twi_mngr;..\..\..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\..\..\components\libraries\usbd\config;..\..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\..\..\components\toolchain\cmsis\include;..\..\..;..\..\..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\..\..\external\lwip\src\include;..\..\..\..\..\..\..\..\external\lwip\src\include\lwip;..\..\..\..\..\..\..\..\external\lwip\src\include\netif;..\..\..\..\..\..\..\..\external\lwip\src\port;..\..\..\..\..\..\..\..\external\lwip\src\port\arch;..\..\..\..\..\..\..\..\external\mbedtls\include;..\..\..\..\..\..\..\..\external\segger_rtt;..\config
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=5 NRF_TLS_MAX_INSTANCE_COUNT=1 S132 SOFTDEVICE_PRESENT SWI_DISABLE0 __HEAP_SIZE=0 __STACK_SIZE=4608
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=5,-DNRF_TLS_MAX_INSTANCE_COUNT=1,-DS132,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0,-D__HEAP_SIZE=0,-D__STACK_SIZE=4608
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x23000 size 0x5d000
  memory RVCT9: RAM 0x20001d88 size 0xe278
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../../../components/boards/: boards.c
  group Board Support
    ../../../../../../../../components/libraries/bsp/: bsp.c bsp_nfc.c
  group Device
    ../../../../../../../../components/toolchain/arm/: arm_startup_nrf52.s
    ../../../../../../../../components/toolchain/: system_nrf52.c
  group lwIP
    ../../../../../../../../external/lwip/src/core/: def.c dhcp.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../../../../external/lwip/src/core/ipv6/: dhcp6.c icmp6.c inet6.c ip6.c ip6_addr.c mld6.c nd6.c
    ../../../../../../../../external/lwip/src/core/ipv4/: icmp.c ip4.c ip4_addr.c
    ../../../../../../../../external/lwip/src/port/: nrf_platform_port.c
  group nRF_BLE
    ../../../../../../../../components/ble/common/: ble_advdata.c ble_srv_common.c
  group nRF_BLE_Services
    ../../../../../../../../components/ble/ble_services/ble_ipsp/: ble_ipsp.c
  group nRF_Drivers
    ../../../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../../../components/drivers_nrf/rng/: nrf_drv_rng.c
    ../../../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../../../components/drivers_nrf/hal/: nrf_nvmc.c
  group nRF_IoT
    ../../../../../../../../components/iot/ble_6lowpan/: ble_6lowpan.c
    ../../../../../../../../components/iot/errno/: errno.c
    ../../../../../../../../components/iot/context_manager/: iot_context_manager.c
    ../../../../../../../../components/iot/iot_timer/: iot_timer.c
    ../../../../../../../../components/iot/medium/: ipv6_medium_ble.c
    ../../../../../../../../components/iot/mqtt/: mqtt.c mqtt_decoder.c mqtt_encoder.c mqtt_rx.c mqtt_transport.c mqtt_transport_lwip.c mqtt_transport_tls.c
  group nRF_IoT_Commissioning
    ../../../../../../../../components/iot/medium/ble_ncfgs/: ble_ncfgs.c
    ../../../../../../../../components/iot/medium/commissioning/: commissioning.c
  group nRF_Libraries
    ../../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../../../components/libraries/fds/: fds.c
    ../../../../../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c nrf_fstorage_sd.c
    ../../../../../../../../components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../../../../../components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_TLS
    ../../../../../../../../external/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c xtea.c
    ../../../../../../../../components/drivers_ext/tls/mbedtls/: tls_interface.c
target flash_s132_nrf52_5.0.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: as above
  output: s132_nrf52_5.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c misc: --c99 --reduce_paths
  c include: ..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x23000 size 0x5d000
  memory RVCT9: RAM 0x20001d88 size 0xe278
  link misc: --diag_suppress 6330
