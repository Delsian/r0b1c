# Keil uVision project ble_ant_app_hrm_pca10040_s332_uart.uvproj, settings and files
target nrf52832_xxaa (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1
  c define: ANT_STACK_SUPPORT_REQD BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=5 S332 SVCALL_AS_NORMAL_FUNCTION SWI_DISABLE0
  c misc: --c99 --reduce_paths
  c include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ant\ant_channel_config;..\..\..\..\..\..\components\ant\ant_key_manager;..\..\..\..\..\..\components\ant\ant_key_manager\config;..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm;..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm\pages;..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm\utils;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\experimental_log;..\..\..\..\..\..\components\libraries\experimental_log\src;..\..\..\..\..\..\components\libraries\experimental_memobj;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\serialization\application\codecs\ant\serializers;..\..\..\..\..\..\components\serialization\application\codecs\ble\serializers;..\..\..\..\..\..\components\serialization\application\hal;..\..\..\..\..\..\components\serialization\application\transport;..\..\..\..\..\..\components\serialization\common;..\..\..\..\..\..\components\serialization\common\struct_ser\ant;..\..\..\..\..\..\components\serialization\common\struct_ser\ble;..\..\..\..\..\..\components\serialization\common\transport;..\..\..\..\..\..\components\serialization\common\transport\ser_phy;..\..\..\..\..\..\components\serialization\common\transport\ser_phy\config;..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\components\softdevice\s332\headers;..\..\..\..\..\..\components\softdevice\s332\headers;..\..\..\..\..\..\components\softdevice\s332\headers\nrf52;..\..\..\..\..\..\components\softdevice\s332\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\toolchain\cmsis\include;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\segger_rtt;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DANT_STACK_SUPPORT_REQD,-DBLE_STACK_SUPPORT_REQD,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=5,-DS332,-DSVCALL_AS_NORMAL_FUNCTION,-DSWI_DISABLE0
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x200006c8 size 0xf938
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group Board Support
    ../../../../../../components/libraries/bsp/: bsp.c bsp_nfc.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf52.s
    ../../../../../../components/toolchain/: system_nrf52.c
  group nRF_ANT
    ../../../../../../components/ant/ant_channel_config/: ant_channel_config.c
    ../../../../../../components/ant/ant_profiles/ant_hrm/: ant_hrm.c
    ../../../../../../components/ant/ant_profiles/ant_hrm/pages/: ant_hrm_page_0.c ant_hrm_page_1.c ant_hrm_page_2.c ant_hrm_page_3.c ant_hrm_page_4.c
    ../../../../../../components/ant/ant_key_manager/: ant_key_manager.c
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ../../../../../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_BLE_Services
    ../../../../../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../../../components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../../../../components/ble/ble_services/ble_hrs/: ble_hrs.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/hal/: nrf_nvmc.c
    ../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_soc.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/uart/: app_uart.c
    ../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../components/libraries/fds/: fds.c
    ../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../../../../../components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
    ../../../../../../components/libraries/sensorsim/: sensorsim.c
  group nRF_Log
    ../../../../../../components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_Serialization
    ../../../../../../components/serialization/application/codecs/ant/serializers/: ant_acknowledge_message_tx.c ant_active_search_sharing_cycles_get.c ant_active_search_sharing_cycles_set.c ant_adv_burst_config_set.c ant_broadcast_message_tx.c ant_capabilities_get.c ant_channel_assign.c ant_channel_close.c ant_channel_id_get.c ant_channel_id_set.c ant_channel_low_priority_rx_search_timeout_set.c ant_channel_open_with_offset.c ant_channel_period_get.c ant_channel_period_set.c ant_channel_radio_freq_get.c ant_channel_radio_freq_set.c ant_channel_radio_tx_power_set.c ant_channel_rx_search_timeout_set.c ant_channel_status_get.c ant_channel_unassign.c ant_coex_config_get.c ant_coex_config_set.c ant_crypto_channel_enable.c ant_crypto_info_get.c ant_crypto_info_set.c ant_crypto_key_set.c ant_cw_test_mode.c ant_cw_test_mode_init.c ant_enable.c ant_event.c ant_id_list_add.c ant_id_list_config.c ant_lib_config_clear.c ant_lib_config_get.c ant_lib_config_set.c ant_network_address_set.c ant_prox_search_set.c ant_rx_scan_mode_start.c ant_search_channel_priority_set.c ant_search_waveform_set.c ant_stack_reset.c ant_version_get.c
    ../../../../../../components/serialization/common/struct_ser/ant/: ant_struct_serialization.c
    ../../../../../../components/serialization/application/codecs/ble/serializers/: app_ble_gap_sec_keys.c app_ble_user_mem.c ble_app.c ble_event.c ble_evt_app.c ble_gap_app.c ble_gap_evt_app.c ble_gattc_app.c ble_gattc_evt_app.c ble_gatts_app.c ble_gatts_evt_app.c ble_l2cap_app.c ble_l2cap_evt_app.c nrf_soc_app.c
    ../../../../../../components/serialization/application/codecs/ant/middleware/: app_mw_ant.c
    ../../../../../../components/serialization/application/codecs/ble/middleware/: app_mw_ble.c app_mw_ble_gap.c app_mw_ble_gattc.c app_mw_ble_gatts.c app_mw_ble_l2cap.c app_mw_nrf_soc.c
    ../../../../../../components/serialization/common/struct_ser/ble/: ble_gap_struct_serialization.c ble_gatt_struct_serialization.c ble_gattc_struct_serialization.c ble_gatts_struct_serialization.c ble_l2cap_struct_serialization.c ble_struct_serialization.c nrf_soc_struct_serialization.c
    ../../../../../../components/serialization/common/: ble_serialization.c cond_field_serialization.c ser_dbg_sd_str.c
    ../../../../../../components/serialization/application/hal/: ser_app_hal_nrf5x.c ser_app_power_system_off.c
    ../../../../../../components/serialization/common/transport/: ser_hal_transport.c
    ../../../../../../components/serialization/common/transport/ser_phy/: ser_phy_uart.c
    ../../../../../../components/serialization/application/transport/: ser_sd_transport.c ser_softdevice_handler.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ant.c nrf_sdh_ble.c nrf_sdh_soc.c
