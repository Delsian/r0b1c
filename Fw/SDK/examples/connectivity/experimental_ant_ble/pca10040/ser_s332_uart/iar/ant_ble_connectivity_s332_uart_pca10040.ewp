# IAR project ant_ble_connectivity_s332_uart_pca10040.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ANT_STACK_SUPPORT_REQD; BLE_STACK_SUPPORT_REQD; BOARD_PCA10040; BSP_DEFINES_ONLY; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52; NRF52832_XXAA; NRF52_PAN_74; NRF_SD_BLE_API_VERSION=5; S332; SER_CONNECTIVITY; SOFTDEVICE_PRESENT; __HEAP_SIZE=1024; __STACK_SIZE=2048
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\ble\ble_dtm; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\experimental_log; ..\..\..\..\..\..\components\libraries\experimental_log\src; ..\..\..\..\..\..\components\libraries\experimental_memobj; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\serialization\common; ..\..\..\..\..\..\components\serialization\common\struct_ser\ant; ..\..\..\..\..\..\components\serialization\common\struct_ser\ble; ..\..\..\..\..\..\components\serialization\common\transport; ..\..\..\..\..\..\components\serialization\common\transport\ser_phy; ..\..\..\..\..\..\components\serialization\common\transport\ser_phy\config; ..\..\..\..\..\..\components\serialization\connectivity; ..\..\..\..\..\..\components\serialization\connectivity\codecs\ant\middleware; ..\..\..\..\..\..\components\serialization\connectivity\codecs\ant\serializers; ..\..\..\..\..\..\components\serialization\connectivity\codecs\ble\middleware; ..\..\..\..\..\..\components\serialization\connectivity\codecs\ble\serializers; ..\..\..\..\..\..\components\serialization\connectivity\codecs\common; ..\..\..\..\..\..\components\serialization\connectivity\hal; ..\..\..\..\..\..\components\softdevice\common; ..\..\..\..\..\..\components\softdevice\s332\headers; ..\..\..\..\..\..\components\softdevice\s332\headers\nrf52; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ant_ble_connectivity_s332_uart_pca10040.hex
  ILINK.IlinkOutputFile: ant_ble_connectivity_s332_uart_pca10040.out
  ILINK.IlinkIcfFile: ant_ble_connectivity_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../../components/libraries/experimental_log/src/: nrf_log_frontend.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group nRF_Serialization
    ../../../../../../components/serialization/connectivity/codecs/ant/serializers/: ant_acknowledge_message_tx.c ant_active_search_sharing_cycles_get.c ant_active_search_sharing_cycles_set.c ant_adv_burst_config_set.c ant_broadcast_message_tx.c ant_capabilities_get.c ant_channel_assign.c ant_channel_close.c ant_channel_id_get.c ant_channel_id_set.c ant_channel_low_priority_rx_search_timout_set.c ant_channel_open_with_offset.c ant_channel_period_get.c ant_channel_period_set.c ant_channel_radio_freq_get.c ant_channel_radio_freq_set.c ant_channel_radio_tx_power_set.c ant_channel_rx_search_timeout_set.c ant_channel_status_get.c ant_channel_unassign.c ant_coex_config_get.c ant_coex_config_set.c ant_crypto_channel_enable.c ant_crypto_info_get.c ant_crypto_info_set.c ant_crypto_key_set.c ant_cw_test_mode.c ant_cw_test_mode_init.c ant_enable.c ant_event.c ant_event_rx.c ant_id_list_add.c ant_id_list_config.c ant_lib_config_clear.c ant_lib_config_get.c ant_lib_config_set.c ant_network_address_set.c ant_prox_search_set.c ant_rx_scan_mode_start.c ant_search_channel_priority_set.c ant_search_waveform_set.c ant_stack_reset.c ant_version_get.c
    ../../../../../../components/serialization/common/struct_ser/ant/: ant_struct_serialization.c
    ../../../../../../components/serialization/connectivity/codecs/ble/serializers/: ble_conn.c ble_event_enc.c ble_evt_conn.c ble_gap_conn.c ble_gap_evt_conn.c ble_gattc_conn.c ble_gattc_evt_conn.c ble_gatts_conn.c ble_gatts_evt_conn.c ble_l2cap_conn.c ble_l2cap_evt_conn.c conn_ble_gap_sec_keys.c conn_ble_l2cap_sdu_pool.c conn_ble_user_mem.c nrf_soc_conn.c
    ../../../../../../components/serialization/connectivity/codecs/common/: ble_dtm_init.c conn_mw.c conn_mw_nrf_soc.c
    ../../../../../../components/serialization/common/struct_ser/ble/: ble_gap_struct_serialization.c ble_gatt_struct_serialization.c ble_gattc_struct_serialization.c ble_gatts_struct_serialization.c ble_l2cap_struct_serialization.c ble_struct_serialization.c nrf_soc_struct_serialization.c
    ../../../../../../components/serialization/common/: ble_serialization.c cond_field_serialization.c ser_dbg_sd_str.c
    ../../../../../../components/serialization/connectivity/codecs/ant/middleware/: conn_mw_ant.c
    ../../../../../../components/serialization/connectivity/codecs/ble/middleware/: conn_mw_ble.c conn_mw_ble_gap.c conn_mw_ble_gattc.c conn_mw_ble_gatts.c conn_mw_ble_l2cap.c
    ../../../../../../components/serialization/connectivity/hal/: dtm_uart.c
    ../../../../../../components/serialization/connectivity/: ser_conn_cmd_decoder.c ser_conn_dtm_cmd_decoder.c ser_conn_error_handling.c ser_conn_event_encoder.c ser_conn_handlers.c ser_conn_pkt_decoder.c ser_conn_reset_cmd_decoder.c
    ../../../../../../components/serialization/common/transport/: ser_hal_transport.c
    ../../../../../../components/serialization/common/transport/ser_phy/: ser_phy_uart.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group nRF_BLE
    ../../../../../../components/ble/ble_dtm/: ble_dtm.c ble_dtm_hw_nrf52.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf52.s
    ../../../../../../components/toolchain/: system_nrf52.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ant.c nrf_sdh_ble.c nrf_sdh_soc.c
