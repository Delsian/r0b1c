# Keil uVision project wireless_uart_first_pca10056.uvproj, settings and files
target nrf52840_xxaa (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=4 OneElfS=1
  c define: BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA RETARGET_ENABLED=1
  c misc: --c99 --reduce_paths
  c include: ..\..\..\config;..\..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\..\components\device;..\..\..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\..\..\components\experimental_802_15_4;..\..\..\..\..\..\..\..\components\experimental_802_15_4\api\HAL;..\..\..\..\..\..\..\..\components\experimental_802_15_4\api\HAL\nrf52_soc;..\..\..\..\..\..\..\..\components\experimental_802_15_4\api\MAC;..\..\..\..\..\..\..\..\components\experimental_802_15_4\api\PHY;..\..\..\..\..\..\..\..\components\experimental_802_15_4\api\RAL;..\..\..\..\..\..\..\..\components\experimental_802_15_4\api\RAL\nrf52_soc;..\..\..\..\..\..\..\..\components\experimental_802_15_4\api\SecAL;..\..\..\..\..\..\..\..\components\experimental_802_15_4\api\SysAL;..\..\..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\..\..\components\libraries\experimental_log;..\..\..\..\..\..\..\..\components\libraries\experimental_log\src;..\..\..\..\..\..\..\..\components\libraries\experimental_memobj;..\..\..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\..\..\components\toolchain\cmsis\include;..\..\..\..;..\..\..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\..\..\external\segger_rtt;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-DRETARGET_ENABLED=1
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress 6330
  group Application
    ../../../../: assert.c fsm.c main.c retarget.c security.c uart.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../../../components/boards/: boards.c
  group Device
    ../../../../../../../../components/toolchain/arm/: arm_startup_nrf52840.s
    ../../../../../../../../components/toolchain/: system_nrf52840.c
  group nRF_802_15_4
    ../../../../../../../../components/experimental_802_15_4/: 802_15_4_lib_keil.lib
    ../../../../../../../../components/experimental_802_15_4/src/: rng_entity.c sec_aes_entity.c
  group nRF_Drivers
    ../../../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../../components/drivers_nrf/hal/: nrf_ecb.c
    ../../../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
  group nRF_Libraries
    ../../../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../../components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../../../../../components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
